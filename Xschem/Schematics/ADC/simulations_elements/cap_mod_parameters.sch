** sch_path: Xschem/Schematics/ADC/simulations_elements/cap_mod_parameters.sch
**.subckt cap_mod_parameters
v5 VDD GND 1.8
v6 n0_in GND pulse 0 1.8 10m 1n 1n 10m 20m
v7 dummy GND pulse 0 1.8 20m 1n 1n 10m 30m
x2 net1 net6 net5 net9 net3 net7 net4 net8 net2 VDD GND GND GND dummy n0_in GND GND GND GND GND
+ inverter_array
x3 vg_out net4 net8 net6 net7 net3 net5 net2 net1 net9 c_array
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
**** begin user architecture code

* .option SCALE=1e-6
.option method=gear seed=12
.param MF_P=1
.control
save all
tran 0.1m 30m
write cap_plus_inv.raw
plot dummy dummy_out
.endc


**** end user architecture code
.end
