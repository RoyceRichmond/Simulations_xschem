** sch_path: Xschem/Schematics/ADC/simulations_elements/integration.sch
**.subckt integration
x3 GND VDD enable signal out_sw sw
v4 VDD GND 3.3
v5 enable GND pulse 0 3.3 10m 1n 1n .01m 30m
v6 signal GND SIN 1 0.6 100 0 0
x1 out_sw net3 net7 net5 net6 net2 net4 net10 net9 net8 c_array
v1 net1 GND 1.8
x2 net9 net5 net4 net8 net2 net6 net3 net7 net10 net1 GND net1 net1 net1 net1 net1 net1 net1 net1
+ out_inv inverter_array
v2 out_inv GND pulse 1.8 0 11m 1n 1n 1m 30m
R1 signal GND 100e6 m=1
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
**** begin user architecture code

* .option SCALE=1e-8
.option method=gear seed=12
.control
save all
tran 0.005m 40m
write integration.raw
plot enable signal out_sw
.endc


**** end user architecture code
.end
