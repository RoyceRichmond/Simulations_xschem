v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 450 -1440 1250 -1040 {flags=graph
y1=-3.64108
y2=4.30759
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000898521
x2=0.00599764
divx=5
subdivx=1
node="top_caps
bottom_caps"
color=6
dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=1}
B 2 450 -1850 1250 -1450 {flags=graph
y1=-0.399419
y2=3.42263
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000898521
x2=0.00599764
divx=5
subdivx=1
node="d2
d1
d0
sample"
color="4 5 6 10"
dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=3}
B 2 1250 -1850 2050 -1450 {flags=graph
y1=-0.291146
y2=3.37804
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000898521
x2=0.00599764
divx=5
subdivx=1
node="d2_n
d1_n
d0_n"
color="4 5 10"
dataset=-1
unitx=1
logx=0
logy=0
hilight_wave=2}
B 2 2270 -1440 3070 -1040 {flags=graph
y1=-0.277147
y2=2.31274
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000898521
x2=0.00599764
divx=5
subdivx=1
node="top_caps_alt
bottom_caps_alt"
color="4 6"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 4140 -1420 4940 -1020 {flags=graph
y1=-0.188569
y2=2.10908
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000898521
x2=0.00599764
divx=5
subdivx=1
node="top_caps_semi
bottom_caps_semi"
color="6 5"
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 6050 -1350 6850 -950 {flags=graph
y1=-0.214335
y2=2.23179
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0.000898521
x2=0.00599764
divx=5
subdivx=1
node="top_caps_sims
bottom_caps_sims"
color="5 6"
dataset=-1
unitx=1
logx=0
logy=0
}
N 100 -750 100 -720 {
lab=GND}
N 100 -830 100 -810 {
lab=VDD}
N 170 -830 170 -810 {
lab=sample}
N 240 -830 310 -830 {
lab=sample}
N 170 -750 170 -720 {
lab=GND}
N 570 -760 600 -760 {
lab=VDD}
N 600 -790 600 -760 {
lab=VDD}
N 570 -690 600 -690 {
lab=GND}
N 600 -690 600 -670 {
lab=GND}
N 510 -790 570 -790 {
lab=vinp}
N 510 -790 510 -710 {
lab=vinp}
N 510 -670 570 -670 {
lab=vinp}
N 510 -710 510 -670 {
lab=vinp}
N 630 -790 700 -790 {
lab=top_caps}
N 700 -790 700 -670 {
lab=top_caps}
N 630 -670 700 -670 {
lab=top_caps}
N 440 -830 600 -830 {
lab=#net1}
N 270 -630 600 -630 {
lab=sample}
N 270 -830 270 -630 {
lab=sample}
N 460 -740 460 -720 {
lab=vinp}
N 460 -740 510 -740 {
lab=vinp}
N 170 -830 240 -830 {
lab=sample}
N 1350 -750 1550 -750 {
lab=top_caps}
N 1170 -750 1350 -750 {
lab=top_caps}
N 960 -750 1170 -750 {
lab=top_caps}
N 700 -750 960 -750 {
lab=top_caps}
N 1220 -360 1220 -290 {
lab=d0}
N 1020 -360 1020 -300 {
lab=d1}
N 810 -360 810 -310 {
lab=d2}
N 1220 -230 1220 -220 {
lab=GND}
N 1020 -240 1020 -230 {
lab=GND}
N 810 -250 810 -230 {
lab=GND}
N 1120 -580 1550 -580 {
lab=#net2}
N 1550 -690 1550 -580 {
lab=#net2}
N 1100 -600 1100 -580 {
lab=d0_n}
N 1100 -600 1350 -600 {
lab=d0_n}
N 1350 -690 1350 -600 {
lab=d0_n}
N 1170 -690 1170 -620 {
lab=d1_n}
N 1080 -620 1170 -620 {
lab=d1_n}
N 1080 -620 1080 -580 {
lab=d1_n}
N 960 -690 1060 -690 {
lab=d2_n}
N 1060 -690 1060 -580 {
lab=d2_n}
N 1120 -420 1160 -420 {
lab=VDD}
N 1160 -430 1160 -420 {
lab=VDD}
N 1100 -420 1100 -400 {
lab=d0}
N 1100 -400 1220 -400 {
lab=d0}
N 1220 -400 1220 -360 {
lab=d0}
N 1080 -420 1080 -360 {
lab=d1}
N 1020 -360 1080 -360 {
lab=d1}
N 1060 -420 1060 -370 {
lab=d2}
N 810 -370 1060 -370 {
lab=d2}
N 810 -370 810 -360 {
lab=d2}
N 570 10 600 10 {
lab=VDD}
N 600 -20 600 10 {
lab=VDD}
N 570 80 600 80 {
lab=GND}
N 600 80 600 100 {
lab=GND}
N 510 -20 570 -20 {
lab=vinn}
N 510 -20 510 60 {
lab=vinn}
N 510 100 570 100 {
lab=vinn}
N 510 60 510 100 {
lab=vinn}
N 440 -60 600 -60 {
lab=#net3}
N 270 140 600 140 {
lab=sample}
N 270 -60 270 140 {
lab=sample}
N 460 30 460 50 {
lab=vinn}
N 460 30 510 30 {
lab=vinn}
N 630 -20 630 100 {
lab=bottom_caps}
N 630 30 720 30 {
lab=bottom_caps}
N 270 -60 310 -60 {
lab=sample}
N 270 -630 270 -60 {
lab=sample}
N 1350 30 1550 30 {
lab=bottom_caps}
N 1170 30 1350 30 {
lab=bottom_caps}
N 960 30 1170 30 {
lab=bottom_caps}
N 1120 200 1550 200 {
lab=#net4}
N 1550 90 1550 200 {
lab=#net4}
N 1100 180 1100 200 {
lab=#net5}
N 1100 180 1350 180 {
lab=#net5}
N 1350 90 1350 180 {
lab=#net5}
N 1170 90 1170 160 {
lab=#net6}
N 1080 160 1170 160 {
lab=#net6}
N 1080 160 1080 200 {
lab=#net6}
N 960 90 1060 90 {
lab=#net7}
N 1060 90 1060 200 {
lab=#net7}
N 1100 360 1100 380 {
lab=d0_n}
N 1100 380 1220 380 {
lab=d0_n}
N 1220 380 1220 420 {
lab=d0_n}
N 1080 360 1080 420 {
lab=d1_n}
N 1020 420 1080 420 {
lab=d1_n}
N 1060 360 1060 410 {
lab=d2_n}
N 810 410 1060 410 {
lab=d2_n}
N 810 410 810 420 {
lab=d2_n}
N 720 30 960 30 {
lab=bottom_caps}
N 390 -830 440 -830 {
lab=#net1}
N 390 -60 440 -60 {
lab=#net3}
N 2130 -710 2130 -690 {
lab=#net8}
N 2130 -710 2180 -710 {
lab=#net8}
N 2970 -710 3170 -710 {
lab=top_caps_alt}
N 2790 -710 2970 -710 {
lab=top_caps_alt}
N 2580 -710 2790 -710 {
lab=top_caps_alt}
N 2320 -710 2580 -710 {
lab=top_caps_alt}
N 2740 -540 3170 -540 {
lab=#net9}
N 3170 -650 3170 -540 {
lab=#net9}
N 2720 -560 2720 -540 {
lab=#net10}
N 2720 -560 2970 -560 {
lab=#net10}
N 2970 -650 2970 -560 {
lab=#net10}
N 2790 -650 2790 -580 {
lab=#net11}
N 2700 -580 2790 -580 {
lab=#net11}
N 2700 -580 2700 -540 {
lab=#net11}
N 2580 -650 2680 -650 {
lab=#net12}
N 2680 -650 2680 -540 {
lab=#net12}
N 2740 -380 2780 -380 {
lab=VDD}
N 2780 -390 2780 -380 {
lab=VDD}
N 2720 -380 2720 -360 {
lab=d0}
N 2720 -360 2840 -360 {
lab=d0}
N 2840 -360 2840 -320 {
lab=d0}
N 2700 -380 2700 -320 {
lab=d1}
N 2640 -320 2700 -320 {
lab=d1}
N 2680 -380 2680 -330 {
lab=d2}
N 2430 -330 2680 -330 {
lab=d2}
N 2430 -330 2430 -320 {
lab=d2}
N 2200 0 2250 0 {
lab=vinn}
N 2370 0 2460 0 {
lab=bottom_caps_alt}
N 3090 0 3290 0 {
lab=bottom_caps_alt}
N 2910 0 3090 0 {
lab=bottom_caps_alt}
N 2700 0 2910 0 {
lab=bottom_caps_alt}
N 2860 170 3290 170 {
lab=#net13}
N 3290 60 3290 170 {
lab=#net13}
N 2840 150 2840 170 {
lab=#net14}
N 2840 150 3090 150 {
lab=#net14}
N 3090 60 3090 150 {
lab=#net14}
N 2910 60 2910 130 {
lab=#net15}
N 2820 130 2910 130 {
lab=#net15}
N 2820 130 2820 170 {
lab=#net15}
N 2700 60 2800 60 {
lab=#net16}
N 2800 60 2800 170 {
lab=#net16}
N 2840 330 2840 350 {
lab=d0_n}
N 2840 350 2960 350 {
lab=d0_n}
N 2960 350 2960 390 {
lab=d0_n}
N 2820 330 2820 390 {
lab=d1_n}
N 2760 390 2820 390 {
lab=d1_n}
N 2800 330 2800 380 {
lab=d2_n}
N 2550 380 2800 380 {
lab=d2_n}
N 2550 380 2550 390 {
lab=d2_n}
N 2460 0 2700 0 {
lab=bottom_caps_alt}
N 5020 -580 5220 -580 {
lab=top_caps_semi}
N 4840 -580 5020 -580 {
lab=top_caps_semi}
N 4630 -580 4840 -580 {
lab=top_caps_semi}
N 4370 -580 4630 -580 {
lab=top_caps_semi}
N 4790 -410 5220 -410 {
lab=#net17}
N 5220 -520 5220 -410 {
lab=#net17}
N 4770 -430 4770 -410 {
lab=#net18}
N 4770 -430 5020 -430 {
lab=#net18}
N 5020 -520 5020 -430 {
lab=#net18}
N 4840 -520 4840 -450 {
lab=#net19}
N 4750 -450 4840 -450 {
lab=#net19}
N 4750 -450 4750 -410 {
lab=#net19}
N 4630 -520 4730 -520 {
lab=#net20}
N 4730 -520 4730 -410 {
lab=#net20}
N 4790 -250 4830 -250 {
lab=VDD}
N 4830 -260 4830 -250 {
lab=VDD}
N 4770 -250 4770 -230 {
lab=d0}
N 4770 -230 4890 -230 {
lab=d0}
N 4890 -230 4890 -190 {
lab=d0}
N 4750 -250 4750 -190 {
lab=d1}
N 4690 -190 4750 -190 {
lab=d1}
N 4730 -250 4730 -200 {
lab=d2}
N 4480 -200 4730 -200 {
lab=d2}
N 4480 -200 4480 -190 {
lab=d2}
N 4300 -80 4390 -80 {
lab=bottom_caps_semi}
N 5020 -80 5220 -80 {
lab=bottom_caps_semi}
N 4840 -80 5020 -80 {
lab=bottom_caps_semi}
N 4630 -80 4840 -80 {
lab=bottom_caps_semi}
N 4790 90 5220 90 {
lab=#net21}
N 5220 -20 5220 90 {
lab=#net21}
N 4770 70 4770 90 {
lab=#net22}
N 4770 70 5020 70 {
lab=#net22}
N 5020 -20 5020 70 {
lab=#net22}
N 4840 -20 4840 50 {
lab=#net23}
N 4750 50 4840 50 {
lab=#net23}
N 4750 50 4750 90 {
lab=#net23}
N 4630 -20 4730 -20 {
lab=#net24}
N 4730 -20 4730 90 {
lab=#net24}
N 4770 250 4770 270 {
lab=d0_n}
N 4770 270 4890 270 {
lab=d0_n}
N 4890 270 4890 310 {
lab=d0_n}
N 4750 250 4750 310 {
lab=d1_n}
N 4690 310 4750 310 {
lab=d1_n}
N 4730 250 4730 300 {
lab=d2_n}
N 4480 300 4730 300 {
lab=d2_n}
N 4480 300 4480 310 {
lab=d2_n}
N 4390 -80 4630 -80 {
lab=bottom_caps_semi}
N 3760 -610 3780 -610 {
lab=GND}
N 3780 -610 3780 -570 {
lab=GND}
N 3760 -580 3760 -570 {
lab=GND}
N 3760 -570 3780 -570 {
lab=GND}
N 3760 -570 3760 -560 {
lab=GND}
N 3760 -670 3760 -640 {
lab=#net25}
N 3760 -760 3760 -730 {
lab=VDD}
N 3760 -700 3800 -700 {
lab=VDD}
N 3800 -740 3800 -700 {
lab=VDD}
N 3760 -740 3800 -740 {
lab=VDD}
N 3720 -700 3720 -610 {
lab=sample}
N 3760 -660 3850 -660 {
lab=#net25}
N 3980 -590 4010 -590 {
lab=VDD}
N 4010 -620 4010 -590 {
lab=VDD}
N 3980 -520 4010 -520 {
lab=GND}
N 4010 -520 4010 -500 {
lab=GND}
N 3920 -620 3980 -620 {
lab=vinp}
N 3920 -620 3920 -540 {
lab=vinp}
N 3920 -500 3980 -500 {
lab=vinp}
N 3920 -540 3920 -500 {
lab=vinp}
N 4040 -620 4110 -620 {
lab=top_caps_semi}
N 4110 -620 4110 -500 {
lab=top_caps_semi}
N 4040 -500 4110 -500 {
lab=top_caps_semi}
N 3850 -660 4010 -660 {
lab=#net25}
N 3680 -460 4010 -460 {
lab=sample}
N 3680 -660 3680 -460 {
lab=sample}
N 3870 -570 3920 -570 {
lab=vinp}
N 4110 -580 4370 -580 {
lab=top_caps_semi}
N 4130 -80 4300 -80 {
lab=bottom_caps_semi}
N 3760 -120 3780 -120 {
lab=GND}
N 3780 -120 3780 -80 {
lab=GND}
N 3760 -90 3760 -80 {
lab=GND}
N 3760 -80 3780 -80 {
lab=GND}
N 3760 -80 3760 -70 {
lab=GND}
N 3760 -180 3760 -150 {
lab=#net26}
N 3760 -270 3760 -240 {
lab=VDD}
N 3760 -210 3800 -210 {
lab=VDD}
N 3800 -250 3800 -210 {
lab=VDD}
N 3760 -250 3800 -250 {
lab=VDD}
N 3720 -210 3720 -120 {
lab=sample}
N 3760 -170 3850 -170 {
lab=#net26}
N 3980 -100 4010 -100 {
lab=VDD}
N 4010 -130 4010 -100 {
lab=VDD}
N 3980 -30 4010 -30 {
lab=GND}
N 4010 -30 4010 -10 {
lab=GND}
N 3920 -130 3980 -130 {
lab=vinn}
N 3920 -130 3920 -50 {
lab=vinn}
N 3920 -10 3980 -10 {
lab=vinn}
N 3920 -50 3920 -10 {
lab=vinn}
N 3850 -170 4010 -170 {
lab=#net26}
N 3680 30 4010 30 {
lab=sample}
N 3680 -170 3680 30 {
lab=sample}
N 3870 -80 3920 -80 {
lab=vinn}
N 4040 -130 4040 -10 {
lab=bottom_caps_semi}
N 4040 -80 4130 -80 {
lab=bottom_caps_semi}
N 3680 -170 3720 -170 {
lab=sample}
N 3680 -460 3680 -170 {
lab=sample}
N 3680 -660 3720 -660 {
lab=sample}
N 7040 -200 7080 -200 {
lab=VDD}
N 7080 -210 7080 -200 {
lab=VDD}
N 7020 -200 7020 -180 {
lab=d0}
N 7020 -180 7140 -180 {
lab=d0}
N 7140 -180 7140 -140 {
lab=d0}
N 7000 -200 7000 -140 {
lab=d1}
N 6940 -140 7000 -140 {
lab=d1}
N 6980 -200 6980 -150 {
lab=d2}
N 6730 -150 6980 -150 {
lab=d2}
N 6730 -150 6730 -140 {
lab=d2}
N 6890 470 6890 490 {
lab=d0_n}
N 6890 490 7010 490 {
lab=d0_n}
N 7010 490 7010 530 {
lab=d0_n}
N 6870 470 6870 530 {
lab=d1_n}
N 6810 530 6870 530 {
lab=d1_n}
N 6850 470 6850 520 {
lab=d2_n}
N 6600 520 6850 520 {
lab=d2_n}
N 6600 520 6600 530 {
lab=d2_n}
N 6010 -560 6030 -560 {
lab=GND}
N 6030 -560 6030 -520 {
lab=GND}
N 6010 -530 6010 -520 {
lab=GND}
N 6010 -520 6030 -520 {
lab=GND}
N 6010 -520 6010 -510 {
lab=GND}
N 6010 -620 6010 -590 {
lab=#net27}
N 6010 -710 6010 -680 {
lab=VDD}
N 6010 -650 6050 -650 {
lab=VDD}
N 6050 -690 6050 -650 {
lab=VDD}
N 6010 -690 6050 -690 {
lab=VDD}
N 5970 -650 5970 -560 {
lab=sample}
N 6010 -610 6100 -610 {
lab=#net27}
N 6230 -540 6260 -540 {
lab=VDD}
N 6260 -570 6260 -540 {
lab=VDD}
N 6230 -470 6260 -470 {
lab=GND}
N 6260 -470 6260 -450 {
lab=GND}
N 6170 -570 6230 -570 {
lab=vinp}
N 6170 -570 6170 -490 {
lab=vinp}
N 6170 -450 6230 -450 {
lab=vinp}
N 6170 -490 6170 -450 {
lab=vinp}
N 6290 -570 6360 -570 {
lab=top_caps_sims}
N 6360 -570 6360 -450 {
lab=top_caps_sims}
N 6290 -450 6360 -450 {
lab=top_caps_sims}
N 6100 -610 6260 -610 {
lab=#net27}
N 5930 -410 6260 -410 {
lab=sample}
N 5930 -610 5930 -410 {
lab=sample}
N 6120 -520 6170 -520 {
lab=vinp}
N 6010 -70 6030 -70 {
lab=GND}
N 6030 -70 6030 -30 {
lab=GND}
N 6010 -40 6010 -30 {
lab=GND}
N 6010 -30 6030 -30 {
lab=GND}
N 6010 -30 6010 -20 {
lab=GND}
N 6010 -130 6010 -100 {
lab=#net28}
N 6010 -220 6010 -190 {
lab=VDD}
N 6010 -160 6050 -160 {
lab=VDD}
N 6050 -200 6050 -160 {
lab=VDD}
N 6010 -200 6050 -200 {
lab=VDD}
N 5970 -160 5970 -70 {
lab=sample}
N 6010 -120 6100 -120 {
lab=#net28}
N 6230 -50 6260 -50 {
lab=VDD}
N 6260 -80 6260 -50 {
lab=VDD}
N 6230 20 6260 20 {
lab=GND}
N 6260 20 6260 40 {
lab=GND}
N 6170 -80 6230 -80 {
lab=vinn}
N 6170 -80 6170 0 {
lab=vinn}
N 6170 40 6230 40 {
lab=vinn}
N 6170 0 6170 40 {
lab=vinn}
N 6100 -120 6260 -120 {
lab=#net28}
N 5930 80 6260 80 {
lab=sample}
N 5930 -120 5930 80 {
lab=sample}
N 6120 -30 6170 -30 {
lab=vinn}
N 6290 -80 6290 40 {
lab=bottom_caps_sims}
N 6290 -30 6380 -30 {
lab=bottom_caps_sims}
N 5930 -120 5970 -120 {
lab=sample}
N 5930 -410 5930 -120 {
lab=sample}
N 5930 -610 5970 -610 {
lab=sample}
N 7040 -520 7040 -360 {
lab=#net29}
N 7000 -520 7020 -360 {
lab=#net30}
N 6960 -520 7000 -360 {
lab=#net31}
N 6920 -520 6980 -360 {
lab=#net32}
N 6360 -540 7080 -640 {
lab=top_caps_sims}
N 6340 -30 6940 70 {
lab=bottom_caps_sims}
N 6900 190 6910 310 {
lab=#net33}
N 6860 190 6890 310 {
lab=#net34}
N 6820 190 6870 310 {
lab=#net35}
N 6780 190 6850 310 {
lab=#net36}
C {devices/code.sym} 1280 -1310 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

"
spice_ignore=false}
C {devices/code_shown.sym} 1400 -1330 0 0 {name=ngspice1
only_toplevel=false
place=end
value="* .option SCALE=1e-6
.option method=gear seed=12
.control
.param mult=83
.param v_pp=1.8
.param vinp=0
.param vinn=v_pp-vinp
save all
tran 0.1m 5m
write re_remake_a.raw
*plot top_caps bottom_caps
.endc
"}
C {devices/vsource.sym} 170 -780 0 0 {name=v1 value="pulse \{v_pp\} 0 1m 1n 1n 5m 5m"}
C {devices/vsource.sym} 100 -780 0 0 {name=v4 value="\{v_pp\}"}
C {devices/vdd.sym} 100 -830 0 0 {name=l3 lab=VDD}
C {devices/gnd.sym} 100 -720 0 0 {name=l4 lab=GND}
C {devices/gnd.sym} 170 -720 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} 270 -830 1 0 {name=p1 sig_type=std_logic lab=sample}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 600 -810 1 0 {name=M3
L=0.3
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 600 -650 3 0 {name=M4
L=0.3
W=1
nf=1 
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 570 -690 1 0 {name=l6 lab=GND}
C {devices/vdd.sym} 570 -760 3 0 {name=l7 lab=VDD}
C {devices/vsource.sym} 460 -690 0 0 {name=v2 value="\{vinp\}"}
C {devices/gnd.sym} 460 -660 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 490 -740 1 0 {name=p3 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 700 -790 1 0 {name=p4 sig_type=std_logic lab=top_caps}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 1550 -720 0 0 {name=C1 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 1350 -720 0 0 {name=C2 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 1170 -720 0 0 {name=C3 model=cap_mim_m3_1 W=1 L=1 MF=2*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 960 -720 0 0 {name=C4 model=cap_mim_m3_1 W=1 L=1 MF=4*mult spiceprefix=X}
C {devices/vsource.sym} 810 -280 0 0 {name=v3 value="pulse \{v_pp\} 0 2m 1n 1n 3m 5m"}
C {devices/vsource.sym} 1020 -270 0 0 {name=v5 value="pulse 0 \{v_pp\} 2m 1n 1n 1m 5m"}
C {devices/vsource.sym} 1220 -260 0 0 {name=v6 value="pulse 0 \{v_pp\} 3m 1n 1n 1m 5m"}
C {devices/gnd.sym} 810 -230 0 0 {name=l18 lab=GND}
C {devices/gnd.sym} 1020 -230 0 0 {name=l19 lab=GND}
C {devices/gnd.sym} 1220 -220 0 0 {name=l20 lab=GND}
C {devices/lab_pin.sym} 810 -370 1 0 {name=p6 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} 1020 -360 1 0 {name=p7 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} 1220 -350 0 0 {name=p8 sig_type=std_logic lab=d0}
C {devices/lab_pin.sym} 1060 -630 2 0 {name=p5 sig_type=std_logic lab=d2_n}
C {devices/lab_pin.sym} 1170 -620 2 0 {name=p9 sig_type=std_logic lab=d1_n}
C {devices/lab_pin.sym} 1350 -600 2 0 {name=p10 sig_type=std_logic lab=d0_n}
C {devices/launcher.sym} 1370 -1090 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/re_remake_a.raw tran"
}
C {Schematics/ADC/inverter_array/inverter_array.sym} 680 -480 0 0 {name=x1}
C {devices/vdd.sym} 880 -520 0 0 {name=l9 lab=VDD}
C {devices/gnd.sym} 880 -490 0 0 {name=l10 lab=GND}
C {devices/vdd.sym} 1160 -430 0 0 {name=l11 lab=VDD}
C {devices/lab_pin.sym} 720 30 1 0 {name=p14 sig_type=std_logic lab=bottom_caps}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 600 -40 1 0 {name=M23
L=0.3
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 600 120 3 0 {name=M24
L=0.3
W=1
nf=1 
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 570 80 1 0 {name=l33 lab=GND}
C {devices/vdd.sym} 570 10 3 0 {name=l34 lab=VDD}
C {devices/vsource.sym} 460 80 0 0 {name=v8 value="\{vinn\}"}
C {devices/gnd.sym} 460 110 0 0 {name=l35 lab=GND}
C {devices/lab_pin.sym} 490 30 1 0 {name=p17 sig_type=std_logic lab=vinn}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 1550 60 0 0 {name=C5 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 1350 60 0 0 {name=C6 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 1170 60 0 0 {name=C7 model=cap_mim_m3_1 W=1 L=1 MF=2*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 960 60 0 0 {name=C8 model=cap_mim_m3_1 W=1 L=1 MF=4*mult spiceprefix=X}
C {devices/lab_pin.sym} 810 410 1 0 {name=p11 sig_type=std_logic lab=d2_n}
C {devices/lab_pin.sym} 1020 420 1 0 {name=p12 sig_type=std_logic lab=d1_n}
C {devices/lab_pin.sym} 1220 420 0 0 {name=p13 sig_type=std_logic lab=d0_n}
C {Schematics/ADC/inverter_array/inverter_array.sym} 680 300 0 0 {name=x2}
C {devices/vdd.sym} 880 260 0 0 {name=l15 lab=VDD}
C {devices/gnd.sym} 880 290 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 1120 360 3 0 {name=l12 lab=GND}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_tests/not.sym} 350 -830 0 0 {name=x3 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.15 
+ VCCPIN=VDD VSSPIN=GND}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_tests/not.sym} 350 -60 0 0 {name=x4 m=1 
+ W_N=1 L_N=0.15 W_P=2 L_P=0.15 
+ VCCPIN=VDD VSSPIN=GND}
C {devices/lab_pin.sym} 2250 -650 2 0 {name=p2 sig_type=std_logic lab=sample}
C {devices/vsource.sym} 2130 -660 0 0 {name=v10 value="\{vinp\}"}
C {devices/gnd.sym} 2130 -630 0 0 {name=l14 lab=GND}
C {devices/lab_pin.sym} 2370 -710 1 0 {name=p16 sig_type=std_logic lab=top_caps_alt}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 3170 -680 0 0 {name=C9 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 2970 -680 0 0 {name=C10 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 2790 -680 0 0 {name=C11 model=cap_mim_m3_1 W=1 L=1 MF=2*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 2580 -680 0 0 {name=C12 model=cap_mim_m3_1 W=1 L=1 MF=4*mult spiceprefix=X}
C {devices/lab_pin.sym} 2430 -330 1 0 {name=p18 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} 2640 -320 1 0 {name=p19 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} 2840 -320 0 0 {name=p20 sig_type=std_logic lab=d0}
C {Schematics/ADC/inverter_array/inverter_array.sym} 2300 -440 0 0 {name=x5}
C {devices/vdd.sym} 2500 -480 0 0 {name=l23 lab=VDD}
C {devices/gnd.sym} 2500 -450 0 0 {name=l24 lab=GND}
C {devices/vdd.sym} 2780 -390 0 0 {name=l25 lab=VDD}
C {Schematics/ADC/sw/sw.sym} 2030 -720 0 0 {name=x6}
C {devices/vdd.sym} 2180 -740 0 0 {name=l26 lab=VDD}
C {devices/gnd.sym} 2180 -680 0 0 {name=l27 lab=GND}
C {devices/lab_pin.sym} 2460 0 1 0 {name=p15 sig_type=std_logic lab=bottom_caps_alt}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 3290 30 0 0 {name=C13 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 3090 30 0 0 {name=C14 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 2910 30 0 0 {name=C15 model=cap_mim_m3_1 W=1 L=1 MF=2*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 2700 30 0 0 {name=C16 model=cap_mim_m3_1 W=1 L=1 MF=4*mult spiceprefix=X}
C {devices/lab_pin.sym} 2550 380 1 0 {name=p22 sig_type=std_logic lab=d2_n}
C {Schematics/ADC/inverter_array/inverter_array.sym} 2420 270 0 0 {name=x7}
C {devices/vdd.sym} 2620 230 0 0 {name=l17 lab=VDD}
C {devices/gnd.sym} 2620 260 0 0 {name=l21 lab=GND}
C {devices/gnd.sym} 2860 330 3 0 {name=l22 lab=GND}
C {Schematics/ADC/sw/sw.sym} 2090 -10 0 0 {name=x9}
C {devices/lab_pin.sym} 2310 60 2 0 {name=p21 sig_type=std_logic lab=sample}
C {devices/gnd.sym} 2240 30 0 0 {name=l1 lab=GND}
C {devices/vdd.sym} 2240 -30 0 0 {name=l2 lab=VDD}
C {devices/lab_pin.sym} 2760 390 1 0 {name=p23 sig_type=std_logic lab=d1_n}
C {devices/lab_pin.sym} 2960 390 0 0 {name=p24 sig_type=std_logic lab=d0_n}
C {devices/lab_pin.sym} 2210 0 1 0 {name=p25 sig_type=std_logic lab=vinn}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 5220 -550 0 0 {name=C17 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 5020 -550 0 0 {name=C18 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 4840 -550 0 0 {name=C19 model=cap_mim_m3_1 W=1 L=1 MF=2*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 4630 -550 0 0 {name=C20 model=cap_mim_m3_1 W=1 L=1 MF=4*mult spiceprefix=X}
C {devices/lab_pin.sym} 4480 -200 1 0 {name=p28 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} 4690 -190 1 0 {name=p29 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} 4890 -190 0 0 {name=p30 sig_type=std_logic lab=d0}
C {Schematics/ADC/inverter_array/inverter_array.sym} 4350 -310 0 0 {name=x8}
C {devices/vdd.sym} 4550 -350 0 0 {name=l28 lab=VDD}
C {devices/gnd.sym} 4550 -320 0 0 {name=l29 lab=GND}
C {devices/vdd.sym} 4830 -260 0 0 {name=l30 lab=VDD}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 5220 -50 0 0 {name=C21 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 5020 -50 0 0 {name=C22 model=cap_mim_m3_1 W=1 L=1 MF=1*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 4840 -50 0 0 {name=C23 model=cap_mim_m3_1 W=1 L=1 MF=2*mult spiceprefix=X}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/cap_mim_m3_1.sym} 4630 -50 0 0 {name=C24 model=cap_mim_m3_1 W=1 L=1 MF=4*mult spiceprefix=X}
C {devices/lab_pin.sym} 4480 300 1 0 {name=p32 sig_type=std_logic lab=d2_n}
C {Schematics/ADC/inverter_array/inverter_array.sym} 4350 190 0 0 {name=x11}
C {devices/vdd.sym} 4550 150 0 0 {name=l36 lab=VDD}
C {devices/gnd.sym} 4550 180 0 0 {name=l37 lab=GND}
C {devices/gnd.sym} 4790 250 3 0 {name=l38 lab=GND}
C {devices/lab_pin.sym} 4690 310 1 0 {name=p34 sig_type=std_logic lab=d1_n}
C {devices/lab_pin.sym} 4890 310 0 0 {name=p35 sig_type=std_logic lab=d0_n}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 3740 -610 0 0 {name=M1
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 3740 -700 0 0 {name=M2
L=0.15
W=2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3760 -560 0 0 {name=l41 lab=GND}
C {devices/vdd.sym} 3760 -760 0 0 {name=l42 lab=VDD}
C {devices/lab_pin.sym} 3680 -660 1 0 {name=p37 sig_type=std_logic lab=sample}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 4010 -640 1 0 {name=M5
L=0.3
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 4010 -480 3 0 {name=M6
L=0.3
W=1
nf=1 
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3980 -520 1 0 {name=l46 lab=GND}
C {devices/vdd.sym} 3980 -590 3 0 {name=l47 lab=VDD}
C {devices/lab_pin.sym} 3900 -570 1 0 {name=p39 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 4110 -620 1 0 {name=p40 sig_type=std_logic lab=top_caps_semi}
C {devices/lab_pin.sym} 4130 -80 1 0 {name=p50 sig_type=std_logic lab=bottom_caps_semi}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 3740 -120 0 0 {name=M25
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 3740 -210 0 0 {name=M26
L=0.15
W=2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3760 -70 0 0 {name=l70 lab=GND}
C {devices/vdd.sym} 3760 -270 0 0 {name=l71 lab=VDD}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 4010 -150 1 0 {name=M27
L=0.3
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 4010 10 3 0 {name=M28
L=0.3
W=1
nf=1 
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 3980 -30 1 0 {name=l72 lab=GND}
C {devices/vdd.sym} 3980 -100 3 0 {name=l73 lab=VDD}
C {devices/lab_pin.sym} 3900 -80 1 0 {name=p51 sig_type=std_logic lab=vinn}
C {devices/lab_pin.sym} 6730 -150 1 0 {name=p26 sig_type=std_logic lab=d2}
C {devices/lab_pin.sym} 6940 -140 1 0 {name=p27 sig_type=std_logic lab=d1}
C {devices/lab_pin.sym} 7140 -140 0 0 {name=p31 sig_type=std_logic lab=d0}
C {Schematics/ADC/inverter_array/inverter_array.sym} 6600 -260 0 0 {name=x10}
C {devices/vdd.sym} 6800 -300 0 0 {name=l13 lab=VDD}
C {devices/gnd.sym} 6800 -270 0 0 {name=l31 lab=GND}
C {devices/vdd.sym} 7080 -210 0 0 {name=l32 lab=VDD}
C {devices/lab_pin.sym} 6600 520 1 0 {name=p33 sig_type=std_logic lab=d2_n}
C {Schematics/ADC/inverter_array/inverter_array.sym} 6470 410 0 0 {name=x12}
C {devices/vdd.sym} 6670 370 0 0 {name=l39 lab=VDD}
C {devices/gnd.sym} 6670 400 0 0 {name=l40 lab=GND}
C {devices/gnd.sym} 6910 470 3 0 {name=l43 lab=GND}
C {devices/lab_pin.sym} 6810 530 1 0 {name=p36 sig_type=std_logic lab=d1_n}
C {devices/lab_pin.sym} 7010 530 0 0 {name=p38 sig_type=std_logic lab=d0_n}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 5990 -560 0 0 {name=M7
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 5990 -650 0 0 {name=M8
L=0.15
W=2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6010 -510 0 0 {name=l44 lab=GND}
C {devices/vdd.sym} 6010 -710 0 0 {name=l45 lab=VDD}
C {devices/lab_pin.sym} 5930 -610 1 0 {name=p41 sig_type=std_logic lab=sample}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 6260 -590 1 0 {name=M9
L=0.3
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 6260 -430 3 0 {name=M10
L=0.3
W=1
nf=1 
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6230 -470 1 0 {name=l48 lab=GND}
C {devices/vdd.sym} 6230 -540 3 0 {name=l49 lab=VDD}
C {devices/lab_pin.sym} 6150 -520 1 0 {name=p42 sig_type=std_logic lab=vinp}
C {devices/lab_pin.sym} 6360 -570 1 0 {name=p43 sig_type=std_logic lab=top_caps_sims}
C {devices/lab_pin.sym} 6380 -30 1 0 {name=p44 sig_type=std_logic lab=bottom_caps_sims}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 5990 -70 0 0 {name=M11
L=0.15
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 5990 -160 0 0 {name=M12
L=0.15
W=2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6010 -20 0 0 {name=l50 lab=GND}
C {devices/vdd.sym} 6010 -220 0 0 {name=l51 lab=VDD}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/pfet_01v8.sym} 6260 -100 1 0 {name=M13
L=0.3
W=1
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {/home/richmond/pdk/sky130A/libs.tech/xschem/sky130_fd_pr/nfet_01v8.sym} 6260 60 3 0 {name=M14
L=0.3
W=1
nf=1 
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 6230 20 1 0 {name=l52 lab=GND}
C {devices/vdd.sym} 6230 -50 3 0 {name=l53 lab=VDD}
C {devices/lab_pin.sym} 6150 -30 1 0 {name=p45 sig_type=std_logic lab=vinn}
C {Schematics/ADC/c_array/c_array.sym} 6750 -670 0 0 {name=x13 @value=1
+ MF_F=83}
C {Schematics/ADC/c_array/c_array.sym} 6610 40 0 0 {name=x14 @value=1
+ MF_F=83}
