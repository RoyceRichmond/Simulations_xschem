** sch_path: Schematics/ADC/simulations_adc_various/sim_8bits_b.sch
**.subckt sim_8bits_b
v1 sample GND pulse {v_pp} 0 1m 1n 1n 20m 20m
v4 VDD GND {v_pp}
v2 vinp GND {vinp}
v8 vinn GND {vinn}
v10 net1 GND {vinp}
x1 vn net10 net6 net8 net7 net11 net9 net3 net4 net5 c_array
x3 GND VDD sample net1 vp sw
x4 net4 net8 net9 net5 net11 net7 net10 net6 net3 VDD GND d3_n d4_n GND d0_n d5_n d1_n d2_n d6_n
+ d7_n inverter_array
x2 GND VDD sample vinn vn sw
x5 vp d6_n d2_n d4_n d3_n d7_n d5_n net2 d0_n d1_n c_array
x6 d0_n d4_n d5_n d1_n d7_n d3_n d6_n d2_n net2 VDD GND d3 d4 VDD d0 d5 d1 d2 d6 d7 inverter_array
v12 d7 GND pulse 0 {v_pp} 0m 1n 1n 20m 20m
v3 d6 GND pulse 0 {v_pp} 2m 1n 1n 20m 20m
v5 d5 GND pulse 0 {v_pp} 3m 1n 1n 20m 20m
v6 d4 GND pulse 0 {v_pp} 4m 1n 1n 20m 20m
v7 d3 GND pulse 0 {v_pp} 5m 1n 1n 20m 20m
v9 d2 GND pulse 0 {v_pp} 6m 1n 1n 20m 20m
v11 d1 GND pulse 0 {v_pp} 7m 1n 1n 20m 20m
v13 d0 GND pulse 0 {v_pp} 8m 1n 1n 20m 20m
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt


**** end user architecture code
**.ends
.GLOBAL VDD
.GLOBAL GND
**** begin user architecture code

* .option SCALE=1e-6
.option method=gear seed=12
.control
.param mult=83
.param v_pp=1.8
.param vinp=1.8
.param vinn=v_pp-vinp
save all
tran 0.2m 9m
write sim_8bits_b.raw
set color0=white
set color1=black
set xbrushwidth=5
plot sample+32 d7+28 d6+24 d5+20 d4+16 d3+12 d2+8 d1+4 d0
*plot sample+32 d7_n+28 d6_n+24 d5_n+20 d4_n+16 d3_n+12 d2_n+8 d1_n+4 d0_n
plot vp vn
.endc


**** end user architecture code
.end
