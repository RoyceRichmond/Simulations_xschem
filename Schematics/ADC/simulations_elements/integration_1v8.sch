** sch_path: Schematics/ADC/simulations_elements/integration_1v8.sch
**.subckt integration_1v8
x3 GND VDD enable signal out_sw sw
v4 VDD GND 1.8
v6 signal GND SIN 0.9 0.9 100 0 0
x1 out_sw GND GND GND GND out_inv GND GND GND GND c_array
v2 out_inv GND pulse 1.8 0 11m 1n 1n .1m 30m
R1 signal GND 100e6 m=1
v1 enable GND pulse 0 1.8 10m 1n 1n .1m 30m
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
**** begin user architecture code

* .option SCALE=1e-8
.option method=gear seed=12
.control
save all
tran 0.01m 40m
write integration_1v8.raw
.endc


**** end user architecture code
.end
