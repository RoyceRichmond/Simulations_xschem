** sch_path: Schematics/ADC/simulations_elements/cap_plus_inv.sch
**.subckt cap_plus_inv
v1 VDD GND 1.8
v2 n0_in GND pulse 0 1.8 10m 1n 1n 10m 20m
v3 dummy GND pulse 0 1.8 20m 1n 1n 10m 30m
x1 n0_out net4 net3 net7 net1 net5 net2 net6 n_dummy VDD GND GND GND dummy n0_in GND GND GND GND GND
+ inverter_array
v4 vg_out GND pulse 0 1.8 5m 1n 1n 10m 50m
x2 vg_out net2 net6 net4 net5 net1 net3 n_dummy n0_out net7 c_array
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
**** begin user architecture code

* .option SCALE=1e-6
.option method=gear seed=12
.control
save all
tran 0.1m 30m
write cap_plus_inv.raw
plot n0_in n0_out
plot vg_out
.endc


**** end user architecture code
.end
