** sch_path: Symbols/dac/dac.sch
**.subckt dac vin sample vdd vss vout dummy ctl[7],ctl[6],ctl[5],ctl[4],ctl[3],ctl[2],ctl[1],ctl[0]
*.iopin vin
*.iopin sample
*.iopin vdd
*.iopin vss
*.iopin vout
*.iopin dummy
*.iopin ctl[7],ctl[6],ctl[5],ctl[4],ctl[3],ctl[2],ctl[1],ctl[0]
x1 vout net2 net6 net4 net5 net1 net3 net9 net8 net7 c_array
x2 net8 net4 net3 net7 net1 net5 net2 net6 net9 vdd vss ctl[3] ctl[4] dummy ctl[0] ctl[5] ctl[1]
+ ctl[2] ctl[6] ctl[7] inverter_array
x3 vss vdd sample vin vout sw
**.ends
.end
